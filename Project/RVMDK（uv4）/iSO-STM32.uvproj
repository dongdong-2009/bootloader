# Keil uVision project iSO-STM32.uvproj, settings and files
target Led (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: 流水灯 +hex
  c flags: uC99=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\Led;..\..\User\SysTick;..\..\BSP\UART;..\..\BSP\FLASH;..\..\BSP\Cryptographic;..\..\BSP\private;..\..\STM32_Cryptographic_Library;..\..\STM32_Cryptographic_Library\binary;..\..\STM32_Cryptographic_Library\inc;..\..\STM32_Cryptographic_Library\inc\AES
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h boot_CFG.h
    ../../User/Led/: bsp_led.c
    ../../User/SysTick/: bsp_SysTick.c
  group DOC
    ../../Doc/: readme.txt
  group BSP
    ../../BSP/UART/: uart4.c uart4.h uart1.c uart1.h
    ../../BSP/FLASH/: Flash.c Flash.h
    ../../BSP/Cryptographic/: Cryptographic.c Cryptographic.h
    ../../BSP/private/: private.c private.h
  group LIB
    ../../STM32_Cryptographic_Library/binary/MK-ARM/: M3_CryptoFW_2_0_6.lib
